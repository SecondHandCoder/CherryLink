# IAR project CherryLinkBoot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: CherryLinkBoot.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; __BUILD_BOOT__; __CONFIG_BOOT_SIZE__=0x2000
  ICCARM.CCDiagSuppress: Pe021
  ICCARM.CCIncludePath2: ..\..\bootloader; ..\..\board; ..\..\cherry-usb; ..\..\cherry-usb\common; ..\..\cherry-usb\core; ..\..\cherry-usb\port\ch32; ..\..\cmsis-pack; ..\..\startup
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: CherryLinkBoot.bin
  ILINK.IlinkIcfFile: linker\CherryLinkBoot.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group board
    ../../board/: ch32f205_backup.c ch32f205_clk.c ch32f205_crc.c ch32f205_flash.c ch32f205_usb.c
  group bootloader
    ../../bootloader/: boot_main.c usb_main.c
  group cherry-usb
    ../../cherry-usb/port/ch32/: usb_dc_usbhs.c
    ../../cherry-usb/core/: usbd_core.c
  group startup
    ../../startup/: startup.c

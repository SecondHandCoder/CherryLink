# IAR project CherryLinkApp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: CherryLinkApp.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; __CONFIG_BOOT_SIZE__=0x2000
  ICCARM.CCDiagSuppress: Pe021
  ICCARM.CCIncludePath2: ..\..\application; ..\..\board; ..\..\cherry-usb; ..\..\cherry-usb\class\cdc; ..\..\cherry-usb\common; ..\..\cherry-usb\core; ..\..\cherry-usb\port\ch32; ..\..\cmsis-pack; ..\..\cmsis-dap; ..\..\rt-thread; ..\..\rt-thread\include; ..\..\rt-thread\ipc; ..\..\startup
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: CherryLinkApp.bin
  ILINK.IlinkIcfFile: linker\CherryLinkApp.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group application
    ../../application/: app_main.c usb_main.c
  group board
    ../../board/: ch32f205_backup.c ch32f205_clk.c ch32f205_dap.c ch32f205_rt_thread.c ch32f205_time.c ch32f205_usb.c ch32f205_watchdog.c
  group cherry-usb
    ../../cherry-usb/core/: usbd_core.c
  group cherry-usb/class-cdc
    ../../cherry-usb/class/cdc/: usbd_cdc.c
  group cherry-usb/port
    ../../cherry-usb/port/ch32/: usb_dc_usbhs.c
  group cmsis-dap
    ../../cmsis-dap/: dap_main.c dap_vendor.c jtag.c swd.c
  group rt-thread/context
    ../../rt-thread/libcpu/cortex-m3/: context_iar.S cpuport.c
  group rt-thread/ipc
    ../../rt-thread/ipc/: completion.c ringbuffer.c
  group rt-thread/src
    ../../rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group startup
    ../../startup/: startup.c
    startup/: startup_ch32f20x_app.s

# Keil uVision project CherryLinkApp.uvprojx, settings and files
target CherryLinkApp (6190000::V6.19::ARMCLANG)
  device: CH32F205RB WCH
  pack: Keil.WCH32F2xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CherryLinkApp
  AfterMake: $KARM\ARMCLANG\bin\fromelf.exe --bin --output=build\application\CherryLinkApp.bin build\application\CherryLinkApp.axf
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __CONFIG_BOOT_SIZE__=0x2000
  c include: ..\..\application;..\..\board;..\..\cherry-usb;..\..\cherry-usb\class\cdc;..\..\cherry-usb\common;..\..\cherry-usb\core;..\..\cherry-usb\port\ch32;..\..\cmsis-pack;..\..\cmsis-dap;..\..\rt-thread;..\..\rt-thread\include;..\..\rt-thread\ipc;..\..\startup
  memory RVCT4: ROM 0x8002000 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\linker\CherryLinkApp.sct
  link misc: --entry Reset_Handler
  group application
    ../../application/: app_main.c usb_main.c
  group board
    ../../board/: ch32f205_backup.c ch32f205_clk.c ch32f205_dap.c ch32f205_rt_thread.c ch32f205_time.c ch32f205_usb.c ch32f205_watchdog.c
  group cherry-usb
    ../../cherry-usb/class/cdc/: usbd_cdc.c
    ../../cherry-usb/core/: usbd_core.c
    ../../cherry-usb/port/ch32/: usb_dc_usbhs.c
  group cmsis-dap
    ../../cmsis-dap/: dap_main.c dap_vendor.c jtag.c swd.c
  group rt-thread
    ../../rt-thread/ipc/: completion.c ringbuffer.c
    ../../rt-thread/libcpu/cortex-m3/: context_rvds.S cpuport.c
    ../../rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group startup
    ./startup/: startup_ch32f20x_app.s
    ../../startup/: startup.c

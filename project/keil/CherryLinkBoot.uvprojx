# Keil uVision project CherryLinkBoot.uvprojx, settings and files
target CherryLinkBoot (6190000::V6.19::ARMCLANG)
  device: CH32F205RB WCH
  pack: Keil.WCH32F2xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CherryLinkBoot
  AfterMake: $KARM\ARMCLANG\bin\fromelf.exe --bin --output=build\bootloader\CherryLinkBoot.bin build\bootloader\CherryLinkBoot.axf
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: __BUILD_BOOT__, __CONFIG_BOOT_SIZE__=0x2000
  c include: ..\..\bootloader;..\..\board;..\..\cherry-usb;..\..\cherry-usb\common;..\..\cherry-usb\core;..\..\cherry-usb\port\ch32;..\..\cmsis-pack;..\..\startup
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\linker\CherryLinkBoot.sct
  link misc: --entry Reset_Handler
  group bootloader
    ../../bootloader/: boot_main.c usb_main.c
  group board
    ../../board/: ch32f205_backup.c ch32f205_clk.c ch32f205_flash.c ch32f205_usb.c ch32f205_crc.c
  group cherry-usb
    ../../cherry-usb/core/: usbd_core.c
    ../../cherry-usb/port/ch32/: usb_dc_usbhs.c
  group startup
    ../../startup/: startup.c
